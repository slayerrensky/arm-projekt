# IAR project Project.ewp, settings and files
configuration STM32F401_MB1115B_M (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F401xx; USE_STDPERIPH_DRIVER; I2C_MASTER; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\inc; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F401_MB1115B_M.out
  ILINK.IlinkIcfFile: STM32F4xxx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401_MB1115B_S (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F401xx; USE_STDPERIPH_DRIVER; I2C_SLAVE; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\inc; ..\..\..\Libraries\CMSIS\Include
  ILINK.IlinkOutputFile: STM32F401_MB1115B_S.out
configuration STM32F429_MB1075B_M (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  ICCARM.CCDefines: STM32F429_439xx; USE_STDPERIPH_DRIVER; I2C_MASTER; ARM_MATH_CM4; __FPU_PRESENT=1
  ILINK.IlinkOutputFile: STM32F429_MB1075B_M.out
configuration STM32F429_MB1075B_S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  ICCARM.CCDefines: STM32F429_439xx; USE_STDPERIPH_DRIVER; I2C_SLAVE; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM32F429_MB1075B_S.out
configuration STM32F407_MB997C_M (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER; I2C_MASTER; ARM_MATH_CM4; __FPU_PRESENT=1
  ILINK.IlinkOutputFile: STM32F407_MB997C_M.out
configuration STM32F407_MB997C_S (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER; I2C_SLAVE; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: STM32F407_MB997C_S.out
  group CMSIS
    ../../../Libraries/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_q15.c
    ../../../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
    ../src/: system_stm32f4xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c
  group User
    ../src/: main.c stm32f4xx_it.c
