# Keil uVision project Project.uvproj, settings and files
target STM32F401_MB1115B_M (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER, I2C_MASTER, ARM_MATH_CM4, __FPU_PRESENT=1
  c include: ..\;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: main.c stm32f4xx_it.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_rtc.c
  group CMSIS
    ../src/: system_stm32f4xx.c
    ../../../Libraries/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_cfft_radix4_init_q15.c arm_cfft_radix4_q15.c arm_bitreversal.c
    ../../../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f429_439xx.s
target STM32F401_MB1115B_S (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: as above
  output: STM32F401xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F401xx, USE_STDPERIPH_DRIVER, I2C_SLAVE, ARM_MATH_CM4,  __FPU_PRESENT=1
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc;..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F429_MB1075B_M (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429_439xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER, I2C_MASTER, ARM_MATH_CM4,  __FPU_PRESENT=1
  c include: ..\;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F429_MB1075B_S (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: as above
  output: STM32F429_439xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER, I2C_SLAVE, ARM_MATH_CM4, __FPU_PRESENT=1
  c include: ..\;..\..\..\Libraries\CMSIS\Device\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc;..\..\..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407_MB997C_M (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, I2C_MASTER, ARM_MATH_CM4,  __FPU_PRESENT=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407_MB997C_S (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: STM32F407xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, I2C_SLAVE, ARM_MATH_CM4,  __FPU_PRESENT=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
