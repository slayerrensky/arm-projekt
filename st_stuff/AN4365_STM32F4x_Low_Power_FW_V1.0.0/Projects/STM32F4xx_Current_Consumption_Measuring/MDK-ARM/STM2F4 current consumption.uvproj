# Keil uVision project STM2F4 current consumption.uvproj, settings and files
target STM32F407-Disco MB997C (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM2F4 current consumption
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F40XX,PERFORMANCE_RUN, ITERATIONS=5200, HSE_VALUE=8000000
  c include: ..\inc;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c pwr_modes.c core_portme.c stm32f4xx_it.c
  group CoreMark_bench
    ../src/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c
  group MDK startups
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f401xx.s startup_stm32f429_439xx.s
target STM32F401-Disco MB1115B (ARM-ADS)
  device: STM32F401VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM2F4 current consumption
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER, STM32F401xx, PERFORMANCE_RUN, ITERATIONS=2200,HSE_VALUE=8000000
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target STM32F429-Disco MB1075B (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM2F4 current consumption
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx, PERFORMANCE_RUN, ITERATIONS=6000, HSE_VALUE=8000000
  c include: ..\inc;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\STM32F4xx_StdPeriph_Lib\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
