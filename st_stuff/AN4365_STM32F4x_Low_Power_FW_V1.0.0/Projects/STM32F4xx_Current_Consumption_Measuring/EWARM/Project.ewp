# IAR project Project.ewp, settings and files
configuration STM32F407-Disco MB997C (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX; PROFILE_RUN; ITERATIONS=5200; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F407-Disco MB997C.out
  ILINK.IlinkIcfFile: STM32F4xxx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401-Disco MB1115B (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; PROFILE_RUN; ITERATIONS=2200; HSE_VALUE=8000000
  ILINK.IlinkOutputFile: STM32F401-Disco MB1115B.out
configuration STM32F429-Disco MB1075B (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; PROFILE_RUN; ITERATIONS=6000; HSE_VALUE=8000000
  ILINK.IlinkOutputFile: STM32F429-Disco MB1075B.out
  group CoreMark_bench
    ../src/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40xx.s startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c
  group User
    ../src/: core_portme.c main.c pwr_modes.c stm32f4xx_it.c
