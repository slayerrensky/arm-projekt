# Keil uVision project Blinky.uvprojx, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Flash OPT
    ./: STM32F40xxx_41xxx_OPT.s
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/MDK/Boards/ST/STM32F4-Discovery/Common/: Buttons_F4Discovery.c LED_F4Discovery.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/STM32F407VGTx/: RTE_Device.h startup_stm32f407xx.s system_stm32f4xx.c stm32f4xx_hal_conf.h
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
target STM32F407 Flash (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.30.0, CMSIS:RTOS:Keil RTX 4.74.0, Board Support:Buttons 2.0.0, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:Startup 2.1.0
